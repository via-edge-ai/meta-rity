# WARNING: please update the rity docs if you modify this file

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_i500-skeleton += " \
	file://skeleton.dts \
"
