PACKAGECONFIG:append = " examples "
PACKAGECONFIG:append = " xkbcommon "
