
PACKAGECONFIG:append = " launcher-libseat"

EXTRA_OEMESON += " -Ddeprecated-wl-shell=true"