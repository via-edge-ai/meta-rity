DEPENDS_append = " libevent"
