PACKAGECONFIG_append = " gtk"
