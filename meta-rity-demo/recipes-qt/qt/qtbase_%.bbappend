PACKAGECONFIG:append = " examples "
